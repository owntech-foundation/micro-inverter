File: KiCAD_Files/uVerter.kicad_sch (KiCad schematic)
At the start: 15 parts

Commit message: added on the schematic the changes andres sugested
Parts:
- Logo1: value ~ -> (none)
